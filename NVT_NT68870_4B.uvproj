# Keil uVision project NVT_NT68870_4B.uvproj, settings and files
target NT68870_FPGA_1080 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68870_FPGA_1080 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68870_FPGA,NVT_1920X1080,FLASH_BANK=4,ENABLE_FPGA_MODE
  c include: .\App;.\App\OSD;.\App\User;.\Lib;.\Lib\NT68810 Series;.\Lib\ScalerCfg;.\Phy\Panel;.\Phy\SI\NVT\Board;.\Phy\SI\NVT\Component;.\Phy\SI\NVT\Keypad;.\Sys;.\Sys\SI\NVT;.\Phy\SI\NVT\Keypad\NT68810_MODULE_KEYPAD
  group Common
    ./Sys/: Main.c EmbedCheckSum.c
    ./Lib/: Int.c ScalerAccess.c OSDAPI_Common.c fe2p_large_3.13.LIB STARTUP_A000_1300.A51 set_b62.a51 NT68F631_8bank.a51
    ./Lib/NT68810 Series/: Scaler_DP_Common.c
    ./App/: GamaApi_Common.c
  group Bank0
    ./Lib/: AutoAdj.c Mcu.c McuADC.c McuDDC.c McuIO.c McuHwIIC.c McuMisc.c
    ./Sys/: AutoAdjConfig.c SyncHandler.c ModeHandler.c ModeTable.c ModeSearch.c ModeConfig.c NR.c Nvram.c NvramIIC.c SysAPI.c Misc.c Ram.c FpgaIIC.c AD9884.c
    ./Phy/SI/NVT/Board/: Board.c
    ./Phy/SI/NVT/Keypad/: KeyPad.c
    ./Phy/Panel/: Panel.c
    ./Lib/NT68810 Series/: ScalerReg.c Scaler_Common.c Scaler_HDMI.c Scaler_LedDriver.c Scaler_LVDS.c Scaler_Power.c Scaler_MMU.c Scaler_Sync.c Scaler_TMDS.c Fe2p_API.c McuReg.c Scaler_CSC.c
    ./Phy/SI/NVT/Keypad/NT68870_MODULE_KEYPAD/: KeyPadStressTest.c
  group Bank1
    ./App/OSD/: OSDIndex.c OSDView.c
    ./App/: KeyCtrl.c Gama_4.c DBC.c
    ./Lib/NT68810 Series/: DBCAPI.c
  group Bank2
    ./App/: APPCtrl.c EventHandle.c
    ./App/OSD/: OSDFont.c
  group Bank3
    ./Lib/NT68810 Series/: Scaler_Display.c SRAPI.c LDAPI.c Scaler_MHL.c Scaler_DP.c Scaler_DP_6502.c DPTx.c Scaler_FRC.c
    ./App/: ColorConfig.c LD.c MHL.c USBTypeC.c USBTypeCHandler.c
    ./Lib/: ColorEngine_Large.LIB USBTypeCFPGA.c
    ./Sys/: AT.c EDP.C
    ./App/OSD/: OSDFont_TC.c
  group Bank4
    ./App/User/: UserSetting.c
    ./App/OSD/FOSDView_AOC/: SMOSDView.c
    ./App/OSD/: OSDFunc.c OSDCtrl.c OSDView3.c
    ./App/OSD/OSD_BENQ_V2/: OSDIndex3.c
    ./App/: Gama_3.c
  group Bank5
    ./Lib/NT68810 Series/: Scaler_Dithering.c Scaler_Capture.c Scaler_ADC.c Scaler_NR.c
    ./App/: Gama_2.c
    ./App/OSD/OSD_BENQ_V2/: Logo.c OSDFont_SC.c OSDFont_Europe.c
  group Bank6
    ./Lib/: CEC.c
    ./App/: SR.c Ddcci.c DdcciCtrl.c Gama_byPass.c Gama_1.c
    ./Lib/NT68810 Series/: OSDAPI2.c OSDAPI.c Scaler_PWM.c
    ./App/OSD/: OSDAPI_Indent.c FOSDView.c
    ./App/OSD/OSD_BENQ_V2/: OSDFont_Japan.c
  group Bank7
    ./App/: Gamma.c HDCP.c OD.c
    ./Lib/: GammaAPI.c ODAPI.c ODTransform_Large.LIB
    ./Lib/NT68810 Series/: HDCPAPI.c
    ./App/OSD/OSD_BENQ_V2/: OSDIndex2.c
    ./App/OSD/: OSDView2.c
target NT68870_MODULE_1080P (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68870_MODULE_1080 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68870_MODULE,NVT_1920X1080,FLASH_BANK=8
  c include: .\App;.\App\OSD;.\App\User;.\Lib;.\Lib\NT68810 Series;.\Lib\ScalerCfg;.\Phy\Panel;.\Phy\SI\NVT\Board;.\Phy\SI\NVT\Component;.\Phy\SI\NVT\Keypad;.\Sys;.\Sys\SI\NVT;.\Phy\SI\NVT\Keypad\NT68870_MODULE_KEYPAD
target NT68870_MODULE_1920X1080_FP (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68870_MODULE_1920X1080_FP +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68870_MODULE,NVT_1920X1080_FP,FLASH_BANK=4
  c include: as above
target NT68870_MODULE_2560X1440_FP (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68870_MODULE_2560X1440_FP +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68870_MODULE,NVT_2560X1440_FP,FLASH_BANK=4
  c include: as above
target NT68877_MODULE_1080P (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68877_MODULE_1080 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68877_MODULE,NVT_1920X1080,FLASH_BANK=4
  c include: as above
  link misc: B0(?CO?MODETABLE(0x5000),?CO?SCALER_COMMON,?CO?HDCPAPI)
B1(?CO?OSDFONT(0x5000),?CO?OSDINDEX,?CO?OSDFUNC,?CO?FOSDVIEW)
B2(?CO?GAMMA(0x5000),?CO?COLORCONFIG,?CO?LOGO,?CO?OD,?CO?DBC)
B3(?CO?DDCCI(0x5000),?CO?LD,?CO?MHL,?CO?SCALER_DP_6502)
target NT68879_MODULE_1080P (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68879_MODULE_1080 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68879_MODULE,NVT_1920X1080,FLASH_BANK=4
  c include: as above
target NT68860_MODULE_1080P (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68860_MODULE_1080 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68860_MODULE,NVT_1920X1080,FLASH_BANK=4
  c include: as above
target NT68867_MODULE_1080P (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68867_MODULE_1080 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68867_MODULE,NVT_1920X1080,FLASH_BANK=4
  c include: as above
target NT68869_MODULE_1080P (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68869_MODULE_1080 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68869_MODULE,NVT_1920X1080,FLASH_BANK=4
  c include: as above
target NT68875 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: NT68875_ +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: SCALER_TYPE=NT68870,NT68870_MODULE,LVIEW_2560X1440,FLASH_BANK=8
  c include: as above
